# Keil uVision project UA2103_IAP.uvprojx, settings and files
target UA2103_IAP (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: UA2103_IAP +hex
  c flags: OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030
  c include: .\application\include;.\library\include;.\library\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group library
    ./library/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c system_stm32f0xx.c
  group application
    ./application/src/: main.c stm32_config.c stm32f0xx_it.c uart.c FLASH2EEPROM.c motion.c communicate.c
  group startup
    ./library/startup/: startup_stm32f030.s
